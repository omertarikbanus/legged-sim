Commit message: reduce mass

File: resource/opy_v05/opy_v05.urdf (robot description, URDF)
Before this commit: robot opy_v05, 18 links, 17 joints
Links:
- link opy_v05/base_link_inertia: mass 14.2 -> 5.2
